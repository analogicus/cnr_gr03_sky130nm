v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {CNR_GR03_SKY130NM/DFF.sym} 400 -240 0 0 {name=x1[10:0]}
C {devices/iopin.sym} 120 -380 2 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 120 -360 2 0 {name=p2 lab=VSS}
C {devices/lab_pin.sym} 350 -320 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 350 -160 0 0 {name=p4 sig_type=std_logic lab=VSS}
C {devices/iopin.sym} 120 -240 2 0 {name=p5 lab=EN}
C {devices/lab_pin.sym} 250 -210 0 0 {name=p6 sig_type=std_logic lab=EN}
C {devices/iopin.sym} 120 -300 2 0 {name=p7 lab=D[10:0]}
C {devices/iopin.sym} 120 -280 2 0 {name=p8 lab=Q[10:0]}
C {devices/iopin.sym} 120 -260 2 0 {name=p9 lab=QN[10:0]}
C {devices/lab_pin.sym} 250 -270 0 0 {name=p10 sig_type=std_logic lab=D[10:0]}
C {devices/lab_pin.sym} 440 -270 2 0 {name=p11 sig_type=std_logic lab=Q[10:0]}
C {devices/lab_pin.sym} 440 -210 2 0 {name=p12 sig_type=std_logic lab=QN[10:0]}
