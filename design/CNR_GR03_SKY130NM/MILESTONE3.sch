v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_tests/adder_4bit.sym} 120 -180 0 0 {name=x0}
